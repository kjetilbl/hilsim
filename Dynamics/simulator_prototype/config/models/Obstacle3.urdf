Commit message: Nytt skip

File: Dynamics/simulator_prototype/config/models/Obstacle3.urdf (robot description, URDF)
Before this commit: robot obstacle_3, 1 links, 0 joints
Links:
- link obstacle_3: geometry visual mesh filename=file:///home/uss_deplorables.stl scale=0.1 0.1 0.1
